SRC_URI += "file://user_2018-07-10-17-17-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

