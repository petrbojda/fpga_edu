SRC_URI += "file://user_2019-04-04-16-05-00.cfg \
            file://user_2019-04-05-14-06-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

