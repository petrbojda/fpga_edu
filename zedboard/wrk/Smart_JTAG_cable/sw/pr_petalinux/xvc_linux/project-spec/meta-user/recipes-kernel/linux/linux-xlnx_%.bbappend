SRC_URI += "file://user_2019-04-06-14-12-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

